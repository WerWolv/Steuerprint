# Keil uVision project Steuerprint.uvprojx, settings and files
target Steuerprint (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F413RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Steuerprint
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F413xx
  c misc: --cpp11
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;   ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Peripherals
    ../Src/Netzgeraet/: peripherals_adc.c peripherals_dac.c peripherals_display.c peripherals_encoder.c peripherals_input.c peripherals_time.c peripherals_i2c.c
  group OS
    ../Src/OS/: fonts.cpp layer.cpp os.cpp renderer.cpp screen.cpp screen_home.cpp
  group OS/Widgets
    ../Src/OS/Widgets/: widget.cpp widget_progress.cpp
  group Application/User
    ../Src/: main.cpp usbd_cdc_if.c usbd_conf.c usb_device.c gpio.c i2c.c tim.c adc.c dma.c rtc.c dac.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_desc.c
    ../Inc/: Settings.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_pcd.c stm32f4xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
software components: CMSIS:CORE 4.1.0
